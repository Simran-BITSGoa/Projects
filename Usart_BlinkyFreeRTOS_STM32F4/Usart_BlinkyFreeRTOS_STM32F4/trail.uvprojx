# Keil uVision project trail.uvprojx, settings and files
target SimpleTask (5030076::V5.03 [Build 76]::..\..\Keil\ARM\ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: trail +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\FreeRTOS-Source\include;.\FreeRTOS-Source\portable\RVDS\ARM_CM4F;..\Example
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source
    ./: main.c
  group FreeRTOS
    ./FreeRTOS-Source/: list.c queue.c tasks.c timers.c
    ./FreeRTOS-Source/portable/MemMang/: heap_2.c
    ./FreeRTOS-Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS:CORE 5.5.0, Compiler:I/O:STDOUT 1.2.0, Device:STM32Cube Framework:Classic 1.7.6, Device:STM32Cube HAL:Common 1.7.6, Device:STM32Cube HAL:Cortex 1.7.6, Device:STM32Cube HAL:DMA 1.7.6, Device:STM32Cube HAL:GPIO 1.7.6, Device:STM32Cube HAL:PWR 1.7.6, Device:STM32Cube HAL:RCC 1.7.6, Device:STM32Cube HAL:UART 1.7.6, Device:STM32Cube HAL:USART 1.7.6, Device:Startup 2.6.3
