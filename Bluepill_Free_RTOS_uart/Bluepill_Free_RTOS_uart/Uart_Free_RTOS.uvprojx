# Keil uVision project Uart_Free_RTOS.uvprojx, settings and files
target Target 1 (5030069::V5.03 [Build 69]::..\..\keil4\ARM\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: blink +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Simple_STM32F103RB_LED;.\FreeRTOS-Source\include;.\FreeRTOS-Source\portable\MemMang;.\FreeRTOS-Source\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c
  group FreeRTOS
    ./FreeRTOS-Source/: timers.c queue.c tasks.c list.c event_groups.c croutine.c
    ./FreeRTOS-Source/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOS-Source/portable/MemMang/: heap_2.c
software components: CMSIS-Compiler:CORE 1.0.0, CMSIS-Compiler:STDIN:ITM 1.0.0, CMSIS-Compiler:STDOUT:ITM 1.0.0, CMSIS:CORE 5.5.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
